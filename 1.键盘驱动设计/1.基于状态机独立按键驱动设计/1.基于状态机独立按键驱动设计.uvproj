# Keil uVision project 1.基于状态机独立按键驱动设计.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 1.基于状态机独立按键驱动设计 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c keyboard.c
